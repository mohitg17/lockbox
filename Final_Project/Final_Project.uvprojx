# Keil uVision project Final_Project.uvprojx, settings and files
target Final_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final_Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab5.c DAC.c DAC.h Switch.h Switch.c Music.c Music.h TestSpeaker.c TestSpeaker.h
    ../inc/: PLL.c LaunchPad.c ST7735.c ST7735.h Texas.c Texas.h
    ../../../Documents/GitHub/final_project_ahl672_mg58629_zbt86_hrr592/Final_Project/: Keypad.c Keypad.h Motor.c Motor.h LED.c LED.h
software components: CMSIS:CORE 5.0.2
